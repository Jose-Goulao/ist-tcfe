CIRCUIT_T2_2

.options savecurrents

*********************************************
*	declaracion of components
*********************************************
*nome	entr	saida	valor

R1	N2	N1	1.00359089673kOhm
R2	N3	N2	2.04298963569kOhm
R3 	N5	N2	3.02503141993kOhm
R4 	0	N5	4.05647775356kOhm
R5 	N5	N6	3.07781188185kOhm
R6 	0	N7	2.01277040929kOhm
R7 	N8	N7.	1.01993304256kOhm

Vs	N1	0	AC 1 sin(0 .1 1k)
C	N8	N6	1.03896393154uF

Vaux	N7	N7.	0V

G1	N6	N3	N2	N5	7.23768458527m
H1	N5	N8	Vaux	8.33526265782k

*********************************************
*		 setup graphs
*********************************************
.control
op

set hcopypscolor=0
set color0=white
set color1=black
set color2=red
set color3=blue
set color4=violet
set color5=rgb:3/8/0
set color6=rgb:4/0/0

*********************************************
*		trans & plot
*********************************************

.ic v(n6)=8.5681V v(n8)=0V

tran 1u 20ms

hardcopy trans-2.ps v(n6) v(n1)

*********************************************
*		    close
*********************************************

quit
.endc
