CIRCUIT_T2_4

.options savecurrents

*********************************************
*	 	data import
*********************************************

.include ../doc/Dados_ngs-4.txt

*********************************************
*		 op & print
*********************************************

.control
op

set hcopypscolor=0
set color0=white
set color1=black
set color2=red
set color3=blue
set color4=violet
set color5=rgb:3/8/0
set color6=rgb:4/0/0

*********************************************
*		trans & plot
*********************************************

.ic v(n6)=8.5681V v(n8)=0V

tran 1u 20ms

hardcopy trans-2.eps v(n6) v(n1)

*********************************************
*		    close
*********************************************

quit
.endc
