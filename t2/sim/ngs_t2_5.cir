CIRCUIT_T2_5

.options savecurrents

*********************************************
*	 	data import
*********************************************

.include ../doc/Dados_ngs-5.txt

*********************************************
*		 op & print
*********************************************

.control
op

set hcopypscolor=0
set color0=white
set color1=black
set color2=red
set color3=blue
set color4=violet
set color5=rgb:3/8/0
set color6=rgb:4/0/0

*********************************************
*		  ac & plot
*********************************************

ac dec 1k 0.1 1meg

hardcopy ac-1.eps db(n6) db(n1)

hardcopy ac-2.eps cph(n6) cph(n1)

hardcopy ac-3.eps (180/PI*cph(n6)+90) (180/PI*cph(n1)+90)

*********************************************
*		    close
*********************************************

quit
.endc
